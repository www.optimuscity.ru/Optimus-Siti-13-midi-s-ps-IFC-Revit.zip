Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 13 миди с пс.IFC
Time: 2025-11-26T10:41:04
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 13 миди.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 13 миди.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
